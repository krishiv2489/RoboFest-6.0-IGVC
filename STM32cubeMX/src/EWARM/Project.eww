<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RoboFest 6.0 IGVC.ewp</path>
  </project>
  <batchBuild />
</workspace>
